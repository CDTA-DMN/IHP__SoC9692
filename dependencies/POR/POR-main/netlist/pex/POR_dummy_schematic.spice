.subckt POR VDD VSS
.ends
.end
