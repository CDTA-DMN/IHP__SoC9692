v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 2570 -730 3020 -730 {lab=VLDO}
N 2660 -670 3020 -670 {lab=#net1}
N 2570 -480 2570 -420 {lab=VLDO}
N 2570 -480 2610 -480 {lab=VLDO}
N 2570 -420 2610 -420 {lab=VLDO}
N 2570 -510 2570 -480 {lab=VLDO}
N 2570 -570 2610 -570 {lab=VLDO}
N 2570 -730 2570 -570 {lab=VLDO}
N 2570 -510 2610 -510 {lab=VLDO}
N 2570 -570 2570 -510 {lab=VLDO}
N 2610 -450 2660 -450 {lab=#net1}
N 2610 -540 2660 -540 {lab=#net1}
N 2660 -540 2660 -450 {lab=#net1}
N 2660 -670 2660 -540 {lab=#net1}
N -750 320 -750 340 {lab=#net2}
N -360 320 -360 340 {lab=#net2}
N -470 320 -360 320 {lab=#net2}
N -470 320 -470 340 {lab=#net2}
N -570 320 -470 320 {lab=#net2}
N -570 320 -570 340 {lab=#net2}
N -660 320 -570 320 {lab=#net2}
N -660 320 -660 340 {lab=#net2}
N -750 320 -660 320 {lab=#net2}
N -90 400 390 400 {lab=VSS}
N -560 140 -560 200 {lab=VSS}
N -560 -20 -520 -20 {lab=VSS}
N -560 40 -520 40 {lab=VSS}
N -560 -20 -560 40 {lab=VSS}
N -560 60 -520 60 {lab=VSS}
N -560 40 -560 60 {lab=VSS}
N -560 120 -520 120 {lab=VSS}
N -560 60 -560 120 {lab=VSS}
N -560 140 -520 140 {lab=VSS}
N -560 120 -560 140 {lab=VSS}
N -560 200 -90 200 {lab=VSS}
N -520 170 -390 170 {lab=#net2}
N -520 90 -390 90 {lab=#net2}
N -520 10 -390 10 {lab=#net2}
N -390 170 -390 210 {lab=#net2}
N -390 90 -390 170 {lab=#net2}
N -390 10 -390 90 {lab=#net2}
N -390 210 -210 210 {lab=#net2}
N -210 210 -210 320 {lab=#net2}
N -360 320 -210 320 {lab=#net2}
N -90 200 -90 400 {lab=VSS}
N -750 400 -90 400 {lab=VSS}
N 390 -140 390 -120 {lab=#net3}
N 2050 -250 2160 -250 {lab=VLDO}
N 2050 -430 2100 -430 {lab=VSS}
N 2020 -390 2020 -340 {lab=RESET}
N 2020 -340 2020 -290 {lab=RESET}
N 1910 -430 1910 -410 {lab=#net4}
N 1910 -340 1910 -330 {lab=RESET}
N 1860 -480 1870 -480 {lab=VSS}
N 1860 -300 1860 -200 {lab=VSS}
N 1860 -200 1870 -200 {lab=VSS}
N 1860 -300 1870 -300 {lab=VSS}
N 1860 -380 1870 -380 {lab=VSS}
N 1910 -350 1910 -340 {lab=RESET}
N 1910 -250 1910 -230 {lab=#net5}
N 1910 -250 1990 -250 {lab=#net5}
N 1910 -270 1910 -250 {lab=#net5}
N 1910 -430 1990 -430 {lab=#net4}
N 1910 -450 1910 -430 {lab=#net4}
N 2250 -340 2300 -340 {lab=RESET}
N 1910 -340 2020 -340 {lab=RESET}
N 1810 -540 1810 -340 {lab=VSS}
N 900 60 900 80 {lab=#net6}
N 940 110 960 110 {lab=#net6}
N 960 60 960 110 {lab=#net6}
N 900 60 960 60 {lab=#net6}
N 900 -50 900 60 {lab=#net6}
N 960 110 1040 110 {lab=#net6}
N 1460 -340 1460 -290 {lab=#net7}
N 1500 -340 1500 -320 {lab=#net8}
N 1220 -140 1250 -140 {lab=VBGR}
N 1060 -470 1180 -470 {lab=VLDO}
N 1080 -80 1180 -80 {lab=#net9}
N 1080 -390 1140 -390 {lab=#net10}
N 1080 -390 1080 -340 {lab=#net10}
N 1020 -390 1080 -390 {lab=#net10}
N 980 -340 1080 -340 {lab=#net10}
N 980 -360 980 -340 {lab=#net10}
N 1180 -260 1180 -170 {lab=#net7}
N 1180 -260 1350 -260 {lab=#net7}
N 1180 -360 1180 -260 {lab=#net7}
N 980 -340 980 -170 {lab=#net10}
N 1460 -390 1460 -340 {lab=#net7}
N 910 -140 940 -140 {lab=#net3}
N 1350 -340 1350 -260 {lab=#net7}
N 1350 -340 1460 -340 {lab=#net7}
N 910 -540 910 -140 {lab=#net3}
N 1700 -340 1700 -240 {lab=VSS}
N 1660 -340 1700 -340 {lab=VSS}
N 1700 -170 1700 400 {lab=VSS}
N 1500 -340 1600 -340 {lab=#net8}
N 1500 -360 1500 -340 {lab=#net8}
N 2250 -340 2250 -310 {lab=RESET}
N 2020 -340 2250 -340 {lab=RESET}
N 1570 -540 1810 -540 {lab=VSS}
N 770 -50 900 -50 {lab=#net6}
N 630 -50 650 -50 {lab=VLDO}
N 390 360 390 400 {lab=VSS}
N 390 -140 910 -140 {lab=#net3}
N 390 -190 390 -140 {lab=#net3}
N 2100 400 2250 400 {lab=VSS}
N 390 -730 390 -370 {lab=VLDO}
N 630 -730 630 -50 {lab=VLDO}
N 390 -730 630 -730 {lab=VLDO}
N 1060 -730 1060 -470 {lab=VLDO}
N 630 -730 1060 -730 {lab=VLDO}
N 980 -470 1060 -470 {lab=VLDO}
N 1500 -730 1910 -730 {lab=VLDO}
N 2250 -250 2250 400 {lab=VSS}
N 1700 400 2100 400 {lab=VSS}
N 2160 -730 2160 -250 {lab=VLDO}
N 1910 -730 2160 -730 {lab=VLDO}
N 2020 -250 2020 -110 {lab=#net2}
N 2100 -430 2100 400 {lab=VSS}
N 1910 -380 1960 -380 {lab=#net1}
N 1910 -300 1960 -300 {lab=#net2}
N 1960 -110 1960 -50 {lab=#net2}
N 1080 -80 1080 80 {lab=#net9}
N 980 -80 1080 -80 {lab=#net9}
N 1500 400 1700 400 {lab=VSS}
N 900 140 900 400 {lab=VSS}
N 390 400 900 400 {lab=VSS}
N 780 110 900 110 {lab=#net2}
N 780 260 780 320 {lab=#net2}
N -210 320 780 320 {lab=#net2}
N 1080 140 1080 400 {lab=VSS}
N 900 400 1080 400 {lab=VSS}
N 1080 110 1160 110 {lab=#net2}
N 1160 110 1160 260 {lab=#net2}
N 780 260 1160 260 {lab=#net2}
N 780 110 780 260 {lab=#net2}
N 1180 -110 1180 -80 {lab=#net9}
N 980 -110 980 -80 {lab=#net9}
N 1160 -140 1180 -140 {lab=#net2}
N 1160 50 1160 110 {lab=#net2}
N 980 -140 1160 -140 {lab=#net2}
N 1500 -260 1500 400 {lab=VSS}
N 1080 400 1500 400 {lab=VSS}
N 1500 -290 1560 -290 {lab=#net2}
N 1560 -290 1560 50 {lab=#net2}
N 1160 50 1560 50 {lab=#net2}
N 1160 -50 1160 50 {lab=#net2}
N 1960 -110 2020 -110 {lab=#net2}
N 1960 -200 1960 -110 {lab=#net2}
N 1700 -180 1700 -170 {lab=VSS}
N 1910 -200 1960 -200 {lab=#net2}
N 1960 -300 1960 -200 {lab=#net2}
N 1160 -50 1960 -50 {lab=#net2}
N 1160 -140 1160 -50 {lab=#net2}
N 2160 -730 2570 -730 {lab=VLDO}
N 1910 -730 1910 -510 {lab=VLDO}
N 1960 -480 2020 -480 {lab=#net1}
N 1960 -480 1960 -380 {lab=#net1}
N 1910 -480 1960 -480 {lab=#net1}
N 2020 -650 2020 -480 {lab=#net1}
N 2020 -670 2660 -670 {lab=#net1}
N 2020 -480 2020 -430 {lab=#net1}
N 1500 -730 1500 -420 {lab=VLDO}
N 1060 -730 1500 -730 {lab=VLDO}
N 980 -470 980 -420 {lab=VLDO}
N 1180 -470 1180 -420 {lab=VLDO}
N 1500 -390 1630 -390 {lab=#net1}
N 950 -390 980 -390 {lab=#net1}
N 950 -450 950 -390 {lab=#net1}
N 1630 -450 1660 -450 {lab=#net1}
N 1180 -390 1230 -390 {lab=#net1}
N 1230 -450 1230 -390 {lab=#net1}
N 950 -450 1230 -450 {lab=#net1}
N 1630 -450 1630 -390 {lab=#net1}
N 1230 -450 1630 -450 {lab=#net1}
N 1660 -650 1660 -450 {lab=#net1}
N 1660 -650 2020 -650 {lab=#net1}
N 2020 -670 2020 -650 {lab=#net1}
N 1810 -340 1810 -300 {lab=VSS}
N 1810 -300 1860 -300 {lab=VSS}
N 1860 -380 1860 -300 {lab=VSS}
N 1860 -480 1860 -380 {lab=VSS}
N 1700 -340 1810 -340 {lab=VSS}
N 1700 -170 1910 -170 {lab=VSS}
C {ipin.sym} 390 -730 0 0 {name=p3 lab=VLDO
}
C {iopin.sym} 390 400 0 1 {name=p1 lab=VSS}
C {opin.sym} 2300 -340 0 0 {name=p2 lab=RESET}
C {ipin.sym} 1250 -140 0 1 {name=p4 lab=VBGR}
C {sg13g2_pr/ntap1_ring.sym} 3020 -700 0 0 {name=R39
model=ntap1
spiceprefix=X
w=11.1e-6
l=3.75e-6
rw=0.3e-6
}
C {sg13g2_pr/ntap1_ring.sym} 2900 -700 0 0 {name=R5
model=ntap1
spiceprefix=X
w=5.85e-6
l=3.35e-6
rw=0.3e-6
}
C {sg13g2_pr/ntap1_ring.sym} 2780 -700 0 0 {name=R6
model=ntap1
spiceprefix=X
w=8.45e-6
l=3.05e-6
rw=0.3e-6
}
C {sg13g2_pr/ntap1_ring.sym} 2680 -700 0 0 {name=R7
model=ntap1
spiceprefix=X
w=2.95e-6
l=3.6e-6
rw=0.3e-6
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2590 -540 0 0 {name=M15
l=1u
w=2u
ng=1
m=2
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2590 -450 0 0 {name=M16
l=0.5u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/ptap1_ring.sym} -660 370 2 1 {name=R36
model=ptap1
spiceprefix=X
w=2.6e-6
l=2.3e-6
rw=0.3e-6
}
C {sg13g2_pr/ptap1_ring.sym} -570 370 2 1 {name=R37
model=ptap1
spiceprefix=X
w=2.6e-6
l=3.5e-6
rw=0.3e-6
}
C {sg13g2_pr/ptap1_ring.sym} -470 370 2 1 {name=R38
model=ptap1
spiceprefix=X
w=10.7e-6
l=2.6e-6
rw=0.3e-6
}
C {sg13g2_pr/ptap1_ring.sym} -360 370 2 1 {name=R8
model=ptap1
spiceprefix=X
w=10.7e-6
l=3.2e-6
rw=0.3e-6
}
C {sg13g2_pr/ptap1_ring.sym} -750 370 2 1 {name=R41
model=ptap1
spiceprefix=X
w=7.7e-6
l=2.25e-6
rw=0.3e-6
}
C {sg13g2_pr/sg13_lv_nmos.sym} -540 10 0 0 {name=M17
l=1u
w=1u
ng=1
m=2
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -540 90 0 0 {name=M18
l=1u
w=0.5u
ng=1
m=2
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -540 170 0 0 {name=M19
l=0.5u
w=0.5u
ng=1
m=2
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2020 -270 1 0 {name=M3
l=0.5u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2020 -410 3 0 {name=M4
l=0.5u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1890 -480 0 0 {name=M5
l=0.5u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1890 -380 0 0 {name=M6
l=0.5u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1890 -300 0 0 {name=M8
l=0.5u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1890 -200 0 0 {name=M9
l=0.5u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/rhigh.sym} 390 -90 0 0 {name=R2
w=0.5e-6
l=16.8e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 940 -540 3 0 {name=R3
w=0.5e-6
l=34e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 390 -220 0 0 {name=R1
w=0.5e-6
l=16.8e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 740 -50 3 0 {name=R4
w=0.5e-6
l=9e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1060 110 0 0 {name=M1
l=1u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 920 110 0 1 {name=M2
l=1u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1480 -290 0 0 {name=M7
l=0.8u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1480 -390 0 0 {name=M10
l=0.8u
w=4u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1200 -140 0 1 {name=M11
l=1u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 960 -140 0 0 {name=M12
l=1u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1160 -390 0 0 {name=M13
l=1u
w=2u
ng=1
m=2
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1000 -390 0 1 {name=M14
l=1u
w=2u
ng=1
m=2
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/cap_cmim.sym} 1700 -210 0 0 {name=C1
model=cap_cmim
w=41.52e-6
l=41.52e-6
m=1
spiceprefix=X}
C {sg13g2_pr/rppd.sym} 1630 -340 1 0 {name=R45
w=2e-6
l=7.45e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/cap_cmim.sym} 2250 -280 0 0 {name=C2
model=cap_cmim
w=26.98e-6
l=26.98e-6
m=1
spiceprefix=X}
C {sg13g2_pr/rhigh.sym} 1000 -540 3 0 {name=R9
w=0.5e-6
l=34e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 1060 -540 3 0 {name=R10
w=0.5e-6
l=34e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 1120 -540 3 0 {name=R11
w=0.5e-6
l=34e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 1180 -540 3 0 {name=R12
w=0.5e-6
l=34e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 1240 -540 3 0 {name=R13
w=0.5e-6
l=34e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 1300 -540 3 0 {name=R14
w=0.5e-6
l=34e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 1360 -540 3 0 {name=R15
w=0.5e-6
l=34e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 1420 -540 3 0 {name=R16
w=0.5e-6
l=34e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 1480 -540 3 0 {name=R17
w=0.5e-6
l=34e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 1540 -540 3 0 {name=R18
w=0.5e-6
l=34e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 680 -50 3 0 {name=R19
w=0.5e-6
l=9e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 390 -280 0 0 {name=R20
w=0.5e-6
l=16.8e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 390 -340 0 0 {name=R21
w=0.5e-6
l=16.8e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 390 -30 0 0 {name=R22
w=0.5e-6
l=16.8e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 390 30 0 0 {name=R23
w=0.5e-6
l=16.8e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 390 90 0 0 {name=R24
w=0.5e-6
l=16.8e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 390 150 0 0 {name=R25
w=0.5e-6
l=16.8e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 390 210 0 0 {name=R26
w=0.5e-6
l=16.8e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 390 270 0 0 {name=R27
w=0.5e-6
l=16.8e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 390 330 0 0 {name=R28
w=0.5e-6
l=16.8e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
