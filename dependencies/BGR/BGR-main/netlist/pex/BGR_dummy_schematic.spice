.subckt BGR VDD VSS
.ends
.end
