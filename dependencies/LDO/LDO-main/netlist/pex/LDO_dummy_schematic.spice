.subckt LDO VDD VSS
.ends
.end
